## sdkconfig.defaults
```kconfig
CONFIG_MBEDTLS_DYNAMIC_BUFFER 
CONFIG_MBEDTLS_DYNAMIC_FREE_CONFIG_DATA 
CONFIG_MBEDTLS_DYNAMIC_FREE_CA_CERT
```
